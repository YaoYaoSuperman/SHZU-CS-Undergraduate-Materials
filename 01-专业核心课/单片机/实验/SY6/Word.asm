		ORG 0000H
		LJMP START
		ORG 0003H
		LJMP INT
		ORG 0100H
START:	MOV SP, #60H
		MOV TCON, #000000000B
		MOV IP, #00000001B
		MOV IE, #10000001B
RUN:	MOV A, #0
LOOP:	
		MOV P1, A
		MOV R5, #20
		LCALL DELAY
		CPL  A
		LJMP LOOP
INT: 
		PUSH ACC
		PUSH PSW
		CLR RS1
		SETB RS0
		CLR C
		MOV A, #11111111B
		MOV R4, #16
LOOPR:
		RRC A
		MOV P1, A
		MOV R5,#20
		CALL DELAY
		DJNZ R4,LOOPR
		POP PSW
		POP ACC
		RETI
DELAY:	MOV R6, #50
S1:		MOV R7, #100
		DJNZ R7, $
		DJNZ R6, S1
		DJNZ R5, DELAY
		RET
		END